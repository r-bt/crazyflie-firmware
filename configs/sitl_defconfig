## configs/sitl_defconfig
```kconfig
CONFIG_PLATFORM_SITL=y
CONFIG_CROSS_COMPILE=""

CONFIG_ESTIMATOR_AUTO_SELECT=y
CONFIG_CONTROLLER_AUTO_SELECT=y
```
